Commit message: Add files via upload

File: neptr_description/urdf/neptr.urdf (robot description, URDF)
Before this commit: robot neptr, 6 links, 5 joints
Links:
- removed link camera
- link shin: geometry visual box size=0.05 0.25 0.05
Joints:
- removed joint world_to_camera
